# Keil uVision project proj_stm32g0.uvprojx, settings and files
target proj_stm32g0 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: proj_stm32g0 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32G0B0xx
  c misc: --gnu
  c include: ../Core/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;../Porting;../../../src;../../../example/HelloSimple
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32g0b0xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group EmbeddedGUI
    ../../../src/anim/: egui_animation.c egui_animation_alpha.c egui_animation_color.c egui_animation_resize.c egui_animation_scale_size.c egui_animation_set.c egui_animation_translate.c egui_interpolator.c egui_interpolator_accelerate.c egui_interpolator_accelerate_decelerate.c egui_interpolator_anticipate.c egui_interpolator_anticipate_overshoot.c egui_interpolator_bounce.c egui_interpolator_cycle.c egui_interpolator_decelerate.c egui_interpolator_linear.c egui_interpolator_overshoot.c
    ../../../src/app/: egui_activity.c egui_dialog.c egui_page_base.c egui_toast.c egui_toast_std.c
    ../../../src/background/: egui_background.c egui_background_color.c egui_background_gradient.c egui_background_image.c
    ../../../src/core/: egui_api.c egui_canvas.c egui_canvas_bezier.c egui_canvas_circle_hq.c egui_canvas_compact.c egui_canvas_ellipse.c egui_canvas_gradient.c egui_canvas_line.c egui_canvas_line_hq.c egui_canvas_polygon.c egui_canvas_transform.c egui_canvas_triangle.c egui_common.c egui_core.c egui_core_activity.c egui_core_dialog.c egui_core_toast.c egui_display_driver.c egui_focus.c egui_input.c egui_key_event.c egui_motion_event.c egui_pfb_manager.c egui_platform.c egui_region.c egui_rotation.c egui_scroller.c egui_timer.c egui_touch_driver.c egui_velocity_tracker.c
    ../../../src/font/: egui_font.c egui_font_lattice.c egui_font_std.c
    ../../../src/image/: egui_image.c egui_image_decode_utils.c egui_image_file.c egui_image_qoi.c egui_image_rle.c egui_image_std.c egui_image_svg.c
    ../../../src/mask/: egui_mask.c egui_mask_circle.c egui_mask_gradient.c egui_mask_image.c egui_mask_round_rectangle.c
    ../../../src/resource/: egui_i18n.c egui_res_circle_info.c egui_res_font_material_symbols_common_16_4.c egui_res_font_material_symbols_common_20_4.c egui_res_font_material_symbols_common_24_4.c egui_res_font_montserrat_10_4.c egui_res_font_montserrat_12_4.c egui_res_font_montserrat_14_4.c egui_res_font_montserrat_16_4.c egui_res_font_montserrat_18_4.c egui_res_font_montserrat_20_4.c egui_res_font_montserrat_22_4.c egui_res_font_montserrat_24_4.c egui_res_font_montserrat_26_4.c egui_res_font_montserrat_28_4.c egui_res_font_montserrat_30_4.c egui_res_font_montserrat_32_4.c egui_res_font_montserrat_34_4.c egui_res_font_montserrat_36_4.c egui_res_font_montserrat_38_4.c egui_res_font_montserrat_40_4.c egui_res_font_montserrat_42_4.c egui_res_font_montserrat_44_4.c egui_res_font_montserrat_46_4.c egui_res_font_montserrat_48_4.c egui_res_font_montserrat_8_4.c
    ../../../src/shadow/: egui_shadow.c
    ../../../src/style/: egui_style.c egui_style_transition.c egui_theme.c egui_theme_dark.c egui_theme_light.c
    ../../../src/utils/: egui_fixmath.c egui_sprintf.c egui_utils.c
    ../../../src/utils/simple_ringbuffer/: simple_data_ringbuffer.c simple_ringbuffer.c
    ../../../src/widget/: egui_view.c egui_view_activity_ring.c egui_view_analog_clock.c egui_view_animated_image.c egui_view_arc_slider.c egui_view_autocomplete.c egui_view_button.c egui_view_button_matrix.c egui_view_canvas_panner.c egui_view_canvas_viewport.c egui_view_card.c egui_view_chart_axis.c egui_view_chart_bar.c egui_view_chart_common.c egui_view_chart_line.c egui_view_chart_pie.c egui_view_chart_scatter.c egui_view_checkbox.c egui_view_chips.c egui_view_circle_dirty.c egui_view_circular_progress_bar.c egui_view_combobox.c egui_view_compass.c egui_view_digital_clock.c egui_view_divider.c egui_view_dynamic_label.c egui_view_gauge.c egui_view_grid_view.c egui_view_gridlayout.c egui_view_group.c egui_view_heart_rate.c egui_view_image.c egui_view_image_button.c egui_view_keyboard.c egui_view_label.c egui_view_led.c egui_view_line.c egui_view_linear_value_helper.c egui_view_linearlayout.c egui_view_list.c egui_view_list_view.c egui_view_lyric_scroller.c egui_view_menu.c egui_view_mini_calendar.c egui_view_mp4.c egui_view_notification_badge.c egui_view_number_picker.c egui_view_page_indicator.c egui_view_pattern_lock.c egui_view_progress_bar.c egui_view_radio_button.c egui_view_ring_text_basic.c egui_view_roller.c egui_view_scale.c egui_view_scroll.c egui_view_segmented_control.c egui_view_slider.c egui_view_spangroup.c egui_view_spinner.c egui_view_stepper.c egui_view_stopwatch.c egui_view_switch.c egui_view_tab_bar.c egui_view_table.c egui_view_textblock.c egui_view_textinput.c egui_view_tileview.c egui_view_toggle_button.c egui_view_viewpage.c egui_view_viewpage_cache.c egui_view_virtual_grid.c egui_view_virtual_list.c egui_view_virtual_page.c egui_view_virtual_section_list.c egui_view_virtual_stage.c egui_view_virtual_strip.c egui_view_virtual_tree.c egui_view_virtual_viewport.c egui_view_window.c
  group Porting
    ../Porting/: egui_hal_stm32g0.c egui_port_mcu.c port_main.c
  group example
    ../../../example/HelloSimple/: uicode.c
software components: CMSIS:CORE 4.3.0
