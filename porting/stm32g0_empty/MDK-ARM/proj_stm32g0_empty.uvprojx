# Keil uVision project proj_stm32g0_empty.uvprojx, settings and files
target proj_stm32g0_empty (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: proj_stm32g0_empty +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32G0B0xx
  c misc: --gnu
  c include: ../Core/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;../Porting;../../../src;../../../example/HelloSimple
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32g0b0xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group EmbeddedGUI
    ../../../src/anim/: egui_animation.c egui_animation_alpha.c egui_animation_scale_size.c egui_animation_set.c egui_animation_translate.c egui_interpolator.c egui_interpolator_accelerate.c egui_interpolator_accelerate_decelerate.c egui_interpolator_anticipate.c egui_interpolator_anticipate_overshoot.c egui_interpolator_bounce.c egui_interpolator_cycle.c egui_interpolator_decelerate.c egui_interpolator_linear.c egui_interpolator_overshoot.c
    ../../../src/app/: egui_activity.c egui_dialog.c egui_toast.c egui_toast_std.c
    ../../../src/background/: egui_background.c egui_background_color.c egui_background_image.c
    ../../../src/core/: egui_api.c egui_canvas.c egui_common.c egui_core.c egui_input.c egui_motion_event.c egui_region.c egui_scroller.c egui_theme.c egui_timer.c egui_velocity_tracker.c
    ../../../src/font/: egui_font.c egui_font_lattice.c egui_font_std.c
    ../../../src/image/: egui_image.c egui_image_std.c
    ../../../src/mask/: egui_mask.c egui_mask_circle.c egui_mask_image.c egui_mask_round_rectangle.c
    ../../../src/resource/: egui_res_circle_info.c egui_res_font_montserrat_8_4.c egui_res_font_montserrat_10_4.c egui_res_font_montserrat_12_4.c egui_res_font_montserrat_14_4.c egui_res_font_montserrat_16_4.c egui_res_font_montserrat_18_4.c egui_res_font_montserrat_20_4.c egui_res_font_montserrat_22_4.c egui_res_font_montserrat_24_4.c egui_res_font_montserrat_26_4.c egui_res_font_montserrat_28_4.c egui_res_font_montserrat_30_4.c egui_res_font_montserrat_32_4.c egui_res_font_montserrat_34_4.c egui_res_font_montserrat_36_4.c egui_res_font_montserrat_38_4.c egui_res_font_montserrat_40_4.c egui_res_font_montserrat_42_4.c egui_res_font_montserrat_44_4.c egui_res_font_montserrat_46_4.c egui_res_font_montserrat_48_4.c
    ../../../src/utils/: egui_fixmath.c egui_utils.c
    ../../../src/utils/simple_ringbuffer/: simple_data_ringbuffer.c simple_ringbuffer.c
    ../../../src/widget/: egui_view.c egui_view_button.c egui_view_group.c egui_view_image.c egui_view_label.c egui_view_linearlayout.c egui_view_progress_bar.c egui_view_scroll.c egui_view_switch.c egui_view_viewpage.c egui_view_viewpage_cache.c
  group Porting
    ../Porting/: api_mcu.c port_main.c
  group example
    ../../../example/HelloSimple/: uicode.c
software components: CMSIS:CORE 4.3.0
